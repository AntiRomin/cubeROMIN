# Keil uVision project cubeROMIN.uvprojx, settings and files
target Debug (6220000::V6.22::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: cubeROMIN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32H743xx,DEBUG
  c include: ..\..\lib\CMSIS\Core\Include;..\..\lib\STM32H7\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\lib\STM32H7\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\lib\STM32H7\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\src\main;..\..\src\platform\startup;..\..\src\platform
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\src\platform\link\arm\stm32_flash_h743_2m.sct
  group Drivers/STM32H7xx_HAL_Driver
    ../../lib/STM32H7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c
  group main
    ../../src/main/: main.c
  group main/core
    ../../src/main/core/: init.c tasks.c
  group main/scheduler
    ../../src/main/scheduler/: scheduler.c
  group platform
    ../../src/platform/: persistent.c system_stm32h7xx.c memprot_hal.c
  group platform/config
    ../../src/platform/config/: config.c
  group platform/startup
    ../../src/platform/startup/arm/: startup_stm32h743xx.s
    ../../src/platform/startup/: system_stm32h7xx.c
  group platform/common
    ../../src/platform/common/: system.c
target Release (6220000::V6.22::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: cubeROMIN +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32H743xx
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\src\platform\link\arm\stm32_flash_h743_2m.sct
software components: CMSIS:CORE 6.1.0
